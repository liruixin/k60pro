# IAR project k60_pro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512
  ICCARM.CCIncludePath2: ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers\mcg; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\lptmr; ..\..\src\projects\fire_gpio_demo; ..\..\build; ..\..\src\drivers\gpio
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: k60_pro.hex
  ILINK.IlinkOutputFile: k60_pro.out
  ILINK.IlinkIcfFile: ..\..\build\config files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../src/projects/fire_gpio_demo/: isr.c main.c
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
