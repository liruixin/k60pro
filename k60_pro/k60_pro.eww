<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\build\k60pro_demo\k60_pro.ewp</path>
  </project>
  <batchBuild/>
</workspace>


